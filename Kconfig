## Kconfig
```kconfig
config SECURITY_LSPROBE
	bool "Security probe"
	depends on SECURITY
	default n
	help
	  A permissive linux security module for logging security ops.
```
